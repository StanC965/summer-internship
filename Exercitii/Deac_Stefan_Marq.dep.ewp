# IAR project Deac_Stefan_Marq.dep.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: DLib_Config_Normal.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m324pb ATmega324PB
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$/src/template/cfgm324pb.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 3
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: adc.c adc.h button.c button.h gpio.c gpio.h led.c led.h main.c scheduler.c scheduler.h scheduler_cfg.c scheduler_cfg.h timer.c timer.h usart.c usart.h
