<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Objective2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective6-7.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ObjectiveBmw.ewp</path>
    </project>
    <batchBuild />
</workspace>
