<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Objective6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Task152.ewp</path>
    </project>
    <batchBuild />
</workspace>
