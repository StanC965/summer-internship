<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Objective1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective5.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Objective6.ewp</path>
    </project>
    <batchBuild />
</workspace>
