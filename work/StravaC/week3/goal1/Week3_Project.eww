<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Week3_Project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\goal6\Week3_Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
